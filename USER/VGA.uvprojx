# Keil uVision project VGA.uvprojx, settings and files
target TEST (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F767xx,ARM_MATH_CM7,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1
  c misc: --diag_suppress=177
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SDMMC;..\HARDWARE\NAND;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\SAI;..\HARDWARE\WM8978;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\HARDWARE\JPEGCODEC;..\USMART;..\MALLOC;..\FATFS\exfuns;..\FATFS\src;..\TEXT;..\AUDIOCODEC\wav;..\APP;..\MJPEG;..\PICTURE;..\HARDWARE\TOUCH;..\EMWIN\STemWin\inc;..\EMWIN\STemWin\Config;..\HARDWARE\DISPLAY;..\HARDWARE\BSP;..\HARDWARE\DS18B20;..\HARDWARE\ADC;..\HARDWARE\CAN;..\EMWIN\STemWinHZ;..\HARDWARE\MS7024;..\HARDWARE\DISPLAY
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_nand.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sai.c stm32f7xx_hal_sai_ex.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_jpeg.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: ltdc.c tftlcd.c
    ../HARDWARE/NAND/: ftl.c nand.c nandtester.c
    ../HARDWARE/SDMMC/: sdmmc_sdcard.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/QSPI/: qspi.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SAI/: sai.c
    ../HARDWARE/WM8978/: wm8978.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/JPEGCODEC/: jpegcodec.c jpeg_utils.c
    ../HARDWARE/TOUCH/: touch.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/BSP/: bsp.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/MS7024/: ms7024.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: ff.c diskio.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: text.c fontupd.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c hjpgd.c piclib.c tjpgd.c
  group README
    ../: readme.txt
  group DSP_LIB
    ../DSP_LIB/: arm_cortexM7lfsp_math.lib
  group EMWIN_LIB
    ../EMWIN/STemWin/Lib/: GUI_CM4F_L.lib
  group EMWIN_CONGIG
    ../EMWIN/STemWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf_FlexColor_Template.c
    ../EMWIN/STemWin/OS/: GUI_X.c
  group DISPLAY
    ../HARDWARE/DISPLAY/: display.c bmpdisplay.c
  group RESOURCE
    ../RESOURCE/: sheshidu14.c sheshidu18.c ShowAll720480.c 700car.c 700fan.c 700houtui.c 700jiaosha.c 700jinguang.c 700qianjin.c 700saoshua.c 700shandian.c 700shousha.c 700shuiweidi.c 700wenduji.c 700youzhuan.c 700zuozhuan.c 700kongbai.c 700dianchi.c 700dianchi_error.c
  group font
    ./font/: DS-Digital32.c DS-Digital30.c DS-Digital96.c DS-Digital40.c DS-Digital36.c
  group EMWIN_HZ
    ../EMWIN/STemWinHZ/: GUI_FontHZ12.c GUI_FontHZ16.c GUI_FontHZ24.c GUI_FontHZ32.c GUI_UC_EncodeNone.c GUICharPEx.c Hzfontupdata.c
